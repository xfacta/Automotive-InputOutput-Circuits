File: Datsun Gauges Headlight Inputs.kicad_sch (KiCad schematic)
At the start: 17 parts, among them U1 4050, U2 4049

Commit message: Cleanup
Other:
- moved on the sheet: C2, D1, D5, R1
