File: Datsun Gauges Voltage and Alternator Inputs.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: Cleanup
Other:
- moved on the sheet: C1, C2, C3, C5, D3, D5, R4, R7, R8, R9
